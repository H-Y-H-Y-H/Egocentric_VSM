Commit message: 0901

File: CADandURDF/robot_repo/broken_feet(60)/urdf/broken_feet.urdf (robot description, URDF)
Before this commit: robot broken_feet, 14 links, 13 joints
Links:
- link 32: mass 0.101175040697171 -> 0.0831925653721974
